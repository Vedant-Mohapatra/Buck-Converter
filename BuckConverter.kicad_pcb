# Repository Vedant-Mohapatra/Buck-Converter

## KiCad design BuckConverter.kicad_pcb

Parts:
10VO1: Screw_Terminal_01x02; PhoenixContact_MSTBA_2,5_2-G_1x02_P5.00mm_Horizontal
10V_T2: TestPoint; TestPoint_Keystone_5010-5014_Multipurpose
C1, C6, C7: 10u; C_Disc_D3.8mm_W2.6mm_P2.50mm
C2, C3, C4, C5: 1u; C_Disc_D3.8mm_W2.6mm_P2.50mm
GND_T1, GND_T2, GND_T3, GND_T4, GND_T5, GND_T6, GND_T7, GND_T8: TestPoint; TestPoint_Keystone_5010-5014_Multipurpose
IC2: TPS2832D; SO-8_3.9x4.9mm_P1.27mm; Manufacturer_Part_Number TPS2832D; Mouser Part Number 595-TPS2832D
L1: 7447231101; Manufacturer_Part_Number 7447231101
LOWDR_T4: TestPoint; TestPoint_Keystone_5010-5014_Multipurpose
LOW_Vds_T5: TestPoint; TestPoint_Keystone_5010-5014_Multipurpose
OPAMP_OUT_T8: TestPoint; TestPoint_Keystone_5010-5014_Multipurpose
PWM1: Conn_Coaxial; BNC_Amphenol_B6252HB-NPP3G-50_Horizontal
PWM_T3: TestPoint; TestPoint_Keystone_5010-5014_Multipurpose
Q1, Q2: CSD18534KCS; TO-220-3_Vertical; Manufacturer_Part_Number CSD18534KCS; Mouser Part Number 595-CSD18534KCS
R1: 0.5; R_Axial_DIN0922_L20.0mm_D9.0mm_P30.48mm_Horizontal
R2: 5k; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R3: 20k; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R4, R5: 100; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
U1: TLV2372; SO-8_3.9x4.9mm_P1.27mm
V_L_T7: TestPoint; TestPoint_Keystone_5010-5014_Multipurpose
Vin1: Screw_Terminal_01x02; PhoenixContact_MSTBA_2,5_2-G_1x02_P5.00mm_Horizontal
Vin_T1: TestPoint; TestPoint_Keystone_5010-5014_Multipurpose
Vout1: Screw_Terminal_01x02; PhoenixContact_MSTBA_2,5_2-G_1x02_P5.00mm_Horizontal
Vout_T6: TestPoint; TestPoint_Keystone_5010-5014_Multipurpose

Connections:
10V: 10VO1.1, 10V_T2.1 (1_1), C3.2, IC2.4 (VCC)
10v: C4.1, U1.8 (V+)
BOOT: C5.1, IC2.8 (BOOT)
GND: 10VO1.2, C1.2, C3.1, C4.2, C6.2, C7.2, GND_T1.1 (1_1), GND_T2.1 (1_1), GND_T3.1 (1_1), GND_T4.1 (1_1), GND_T5.1 (1_1), GND_T6.1 (1_1), GND_T7.1 (1_1), GND_T8.1 (1_1), IC2.2 (PGND), PWM1.2 (Ext), Q2.3 (S), R1.1, R2.1, U1.4 (V-), Vin1.2
HIGHDR: IC2.7 (HIGHDR), R4.1
LOWDR: IC2.5 (LOWDR), LOWDR_T4.1 (1_1), R5.1
unnamed: Q1.1 (G), R4.2
unnamed: Q2.1 (G), R5.2
unnamed: R2.2, R3.1, U1.2 (-)
OPAMP_OUT: OPAMP_OUT_T8.1 (1_1), R3.2, U1.1
PWM: IC2.1 (IN), PWM1.1 (In), PWM_T3.1 (1_1)
SW: C5.2, IC2.3 (DT), IC2.6 (BOOTLO), L1.2, LOW_Vds_T5.1 (1_1), Q1.3 (S), Q2.2 (D)
VIN+: C1.1, C6.1, C7.1, Q1.2 (D)
Vin+: Vin1.1, Vin_T1.1 (1_1)
Vout+: C2.1, L1.3, Vout1.1, Vout_T6.1 (1_1)
Vout-: C2.2, R1.2, U1.3 (+), V_L_T7.1 (1_1), Vout1.2

Notes on the sheet:
Power Stage
Gate Driver
Test Points
Current Sensing
Connectors

Board: 2 copper layers, 129.0 x 89.0 mm, 37 parts (0 on the bottom side), 16 nets.
